# Keil uVision project SPI_Transmit.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: SPI_Transmit +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include
  group Source
    ./Code/: main.c XN297L.c
  group Common
    ../Common/: Common.c Delay.c
  group Startup
    ../Startup/: STARTUP.A51
